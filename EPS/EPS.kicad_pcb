# Repository Wilewee/A3EPS

## KiCad design EPS/EPS.kicad_pcb

Board: 4 copper layers, 100.0 x 100.0 mm, 240 parts (39 on the bottom side), 134 nets.

Parts:
3V6_1, 3V6_2: Jst_Conn; JST_XH_B02B-XH-A_02x2.50mm_Straight
100k: therm; Socket_Strip_Straight_1x02_Pitch2.00mm
ABM3: 8 MHz; Crystal_SMD_0603-2pin_6.0x3.5mm
BAT_TEMP: TEST; Measurement_Point_Round-SMD-Pad_Small
BOOT0: BOOT0; Pin_Header_Straight_1x03_Pitch2.54mm
BOOT1: BOOT1; Pin_Header_Straight_1x03_Pitch2.54mm
BQ1: BQ29209; Texas_S-PVSON-N8
BT1: Cell2; 18650_Holder_FULL
BT2: Cell1; 18650_Holder_FULL
BU1: BU33SD5; TSOP-5_1.65x3.05mm_Pitch0.95mm
C1, C4, C5, C8, C9, C10, C11, C15, C16, C23, C24, C25, C44, C45, C46, C49, C50, C53, C54, C55, C56, C57, C59: 0.1u; C_0603
C2, C3, C6: 4.7u; C_0603
C7, C29, C30, C31: 1u; C_0603
C12: 10u; C_0603
C13, C14: 26p; C_0603
C17, C18, C19, C20, C21, C22, C32, C33, C34, C38, C39, C40, C51, C52, C60, C61, C62, C63, C64, C65: CP; CP_Tantalum_Case-C_EIA-6032-28_Reflow
C26, C27, C28: .22u; C_0603
C35, C36, C37: 220p; C_0603
C47, C48, C58: C; C_0603
C_DAC1: 10u; C_0805
C_DAC2: 0.1u; C_0603
D1, D2, D3: D_Schottky; D_SOD-123
D4: LED; LED_0603
DAC1, DAC2, DAC3: TEST; Measurement_Point_Round-SMD-Pad_Small
DX+: MAX40200; SOT-23-5
DX-: MAX40200; SOT-23-5
DY+: MAX40200; SOT-23-5
DY-: MAX40200; SOT-23-5
DZ+: MAX40200; SOT-23-5
DZ-: MAX40200; SOT-23-5
D_EN: TEST; Measurement_Point_Round-SMD-Pad_Small
FB1, FB2, FB3: TEST; Measurement_Point_Round-SMD-Pad_Small
G_NMOS1, G_NMOS2, G_NMOS3: TEST; Measurement_Point_Round-SMD-Pad_Small
G_PMOS1, G_PMOS2, G_PMOS3: TEST; Measurement_Point_Round-SMD-Pad_Small
Ground_Pins1: 2.56_socket_male; Socket_Strip_Straight_1x05_Pitch2.54mm
HEATER_EN: TEST; Measurement_Point_Round-SMD-Pad_Small
Heater: Molex; Molex_KK-6410-02_02x2.54mm_Straight
I1_IN, I1_OUT, I2_IN, I2_OUT, I3_IN, I3_OUT: TEST; Measurement_Point_Round-SMD-Pad_Small
INA1, INA2, INA3, INA4, INA5, INA6, INA7, INA8, INA9: INA210; SOT-363_SC-70-6
J1: CAN_BUS; Pin_Header_Straight_1x03_Pitch2.54mm
J11: ST_LINK; Pin_Header_Straight_1x05_Pitch2.54mm
J12: USART; Pin_Header_Straight_1x02_Pitch2.54mm
L1: 1000 Ohm; R_1206
L2, L3, L4: L; L_Axial_L7.0mm_D3.3mm_P5.08mm_Vertical_Fastron_MICC
L5, L6: L_Small; L_Axial_L7.0mm_D3.3mm_P5.08mm_Vertical_Fastron_MICC
MAX1, MAX2, MAX3: MAX668_669; MSOP-10_3x3mm_Pitch0.5mm
OP1, OP2, OP3: NCS20071; SOT-553
POT1, POT2, POT3: MAX5395; DFN-8_2x2mm_Pitch0.5mm
Q1, Q2, Q3, Q4, Q6, Q7, Q10, Q14: Q_NMOS_GSD; SOT-23
Q5, Q8, Q9: PMOS_DIGITAL_LOAD?; SOT-23
Q11: Q_PMOS_GSD; SOT-23
Q12: Q_NMOS_DGS; SOT-23
Q13, Q15: PMOS_IN; SOT-23
Q16: PMOS_OUT1; SOT-23
Q17: PMOS_OUT2; SOT-23
R1, R2, R57: 10k; R_0603
R3, R4: 120; R_0603
R7, R8, R9, R10, R11, R12, R19, R20, R21, R22, R23, R24, R25, R26, R27, R28, R29, R30, R31, R32, R33, R34, R35, R36, R37, R38, R39, R40, R41, R42, R43, R48, R49, R50, R51, R52, R53, R54, R55, R58, R59, R60, R61: R; R_0603
R13, R14, R15, R44, R46: 100k; R_0603
R16, R17, R18: 20m; R_0805
R45, R47: 19k6; R_0603
R56: 5.4k; R_0603
R65: 100; R_0603
RAW1: Jst_Conn; JST_XH_B02B-XH-A_02x2.50mm_Straight
RBF_control_pins1: 5_pin_2.56; Socket_Strip_Straight_1x05_Pitch2.54mm
R_s1, R_s2, R_s3, R_s4, R_s5, R_s6, R_s7, R_s8, R_s9: R; R_0805
STM1: STM32F446RE; LQFP-64_10x10mm_Pitch0.5mm
Solar_X+: JST_Connector; JST_XH_B02B-XH-A_02x2.50mm_Straight
Solar_X-: JST_Connector; JST_XH_B02B-XH-A_02x2.50mm_Straight
Solar_Y+: JST_Connector; JST_XH_B02B-XH-A_02x2.50mm_Straight
Solar_Y-: JST_Connector; JST_XH_B02B-XH-A_02x2.50mm_Straight
Solar_Z+: JST_Connector; JST_XH_B02B-XH-A_02x2.50mm_Straight
Solar_Z-: JST_Connector; JST_XH_B02B-XH-A_02x2.50mm_Straight
TPS2, TPS3: TPS54302; SOT-23-6
U1: MCP4728; MSOP-10_3x3mm_Pitch0.5mm
U2, U3: SN65HVD232; SOIC-8_3.9x4.9mm_Pitch1.27mm
V1_IN, V1_OUT, V2_IN, V2_OUT, V3_IN, V3_OUT: TEST; Measurement_Point_Round-SMD-Pad_Small

Connections:
+3V3: 100k.2, BOOT0.1, BOOT1.1, BU1.6, C3.1, C4.1, C5.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C15.1, C16.1, C23.1, C24.1, C25.1, C44.1, C45.1, C46.1, C53.1, C54.1, C55.1, C_DAC1.1, C_DAC2.1, INA1.3, INA2.3, INA3.3, INA4.3, INA5.3, INA6.3, INA7.3, INA8.3, INA9.3, J11.1, L1.1, L1.2, POT1.3, POT1.6, POT2.6, POT3.6, STM1.1, STM1.13, STM1.19, STM1.32, STM1.48, STM1.64, U1.1, U2.3, U3.3
/3V6: 3V6_1.2, BU1.1, BU1.3, C2.1, C51.1, C52.1, INA7.5, R_s7.1
/3V6_1: 3V6_2.2, C60.1, C61.1, INA8.5, R_s8.1
/3V6_BUS_SW1: STM1.36, TPS2.5
/3V6_BUS_SW2: STM1.35, TPS3.5
/BATT_V1: R49.2, R51.2, STM1.26
/BATT_V2: R48.2, R50.2, STM1.27
/Battery_pack/BATT+: BT1.1, Heater.1, Q15.2, Q16.2, R50.1, R52.2, R55.1, R56.1, R61.2
/Bus_regulation/3V6_rail/3V6_BUS1: C62.1, INA8.4, L5.2, R44.1, R_s8.2
/Bus_regulation/3V6_rail/3V6_BUS2: C63.1, C65.1, INA7.4, L6.2, R46.1, R_s7.2
/Bus_regulation/Output_rail_telemetry/INA1_BUS-: INA9.5, Q11.2, R43.2, R_s9.1
/Bus_regulation/VIN: C47.1, C48.1, C64.1, INA9.4, Q17.3, R_s9.2, TPS2.3, TPS3.3
/CAN_H: J1.2, R3.1, R4.1, U2.7, U3.7
/CAN_L: J1.3, R3.2, R4.2, U2.6, U3.6
/Connectors_diodes/X+: DX+.1, Solar_X+.2
/Connectors_diodes/X-: DX-.1, Solar_X-.2
/Connectors_diodes/Y+: DY+.1, Solar_Y+.2
/Connectors_diodes/Y-: DY-.1, Solar_Y-.2
/Connectors_diodes/Z+: DZ+.1, Solar_Z+.2
/Connectors_diodes/Z-: DZ-.1, Solar_Z-.2
/DIODE_EN: DX+.3, DX-.3, DY+.3, DY-.3, DZ+.3, DZ-.3, D_EN.1, STM1.51
/HEATER_EN: HEATER_EN.1, Q12.2, R57.1, STM1.52
/I1_3V6_BUS: INA8.6, STM1.22
/I1_IN: I1_IN.1, INA1.6, STM1.8
/I1_OUT: I1_OUT.1, INA4.6, STM1.17
/I2_3V6_BUS: INA7.6, STM1.23
/I2_IN: I2_IN.1, INA2.6, STM1.10
/I2_OUT: I2_OUT.1, INA5.6, STM1.20
/I3_IN: I3_IN.1, INA3.6, STM1.14
/I3_OUT: I3_OUT.1, INA6.6, STM1.21
/INPUT_PWR_SW: R58.1, STM1.37
/I_RAW: INA9.6, STM1.24
/Input/Boost/BOOST1_IN: C32.1, INA1.5, L2.1, R_s3.1
/Input/Boost/BOOST2_IN: C33.1, INA2.5, L3.1, R_s2.1
/Input/Boost/BOOST3_IN: C34.1, INA3.5, L4.1, R_s1.1
/Input/Boost/FB1: C35.1, MAX1.5, POT1.8, R19.2
/Input/Boost/FB2: C36.1, MAX2.5, POT2.8, R20.2
/Input/Boost/FB3: C37.1, MAX3.5, POT3.8, R21.2
/Input/Current_Limiters/BOOSTED_V_1: INA4.5, Q5.2, R25.2, R_s6.1
/Input/Current_Limiters/BOOSTED_V_2: INA5.5, Q8.2, R31.2, R_s5.1
/Input/Current_Limiters/BOOSTED_V_3: INA6.5, Q9.2, R32.2, R_s4.1
/Input/Current_Limiters/DAC1: DAC1.1, R30.1, U1.6
/Input/Current_Limiters/DAC2: DAC2.1, R41.1, U1.7
/Input/Current_Limiters/DAC3: DAC3.1, R42.1, U1.8
/LDAC: STM1.50, U1.4
/RAW_BUS_SW: Q10.1, STM1.38
/RAW_OUT: Q11.3, RAW1.2
/SCL: POT1.5, POT2.5, POT3.5, STM1.41, U1.2
/SDA: POT1.4, POT2.4, POT3.4, STM1.40, U1.3
/STM32_block/BOOT0: BOOT0.2, R1.1
/STM32_block/BOOT1: BOOT1.2, R2.2
/STM32_block/CAN1_RX: STM1.44, U2.4
/STM32_block/CAN1_TX: STM1.45, U2.1
/STM32_block/CAN2_RX: STM1.57, U3.4
/STM32_block/CAN2_TX: STM1.58, U3.1
/STM32_block/NRST: C1.1, J11.5, STM1.7
/STM32_block/OSC_IN: ABM3.1, C13.1, STM1.5
/STM32_block/OSC_OUT: ABM3.2, C14.1, STM1.6
/STM32_block/SWCLK: J11.2, STM1.49
/STM32_block/SWDIO: J11.4, STM1.46
/STM32_block/USART_RX: J12.2, STM1.43
/STM32_block/USART_TX: J12.1, STM1.42
/STM32_block/VCAP: C6.1, STM1.30
/SW1: Q14.1, R58.2, R60.1, RBF_control_pins1.2
/SW2: Q16.1, Q17.1, R61.1, RBF_control_pins1.3
/SW3: BQ1.5, BQ1.6, BT2.2, C57.2, C58.2, C59.2, Q12.3, RBF_control_pins1.5
/TEMP_BATT: 100k.1, BAT_TEMP.1, R56.2, STM1.16
/V1_IN: R7.2, R8.1, STM1.9, V1_IN.1
/V2_IN: R9.2, R10.1, STM1.11, V2_IN.1
/V3_IN: R11.2, R12.1, STM1.15, V3_IN.1
/VBATT_EPS: OP1.5, OP2.5, OP3.5, Q5.3, Q8.3, Q9.3, Q13.2, R59.2
/X_PV: C18.1, C21.1, DX+.5, DX-.5, INA1.4, R7.1, R27.1, R_s3.2
/Y_PV: C19.1, C22.1, DY+.5, DY-.5, INA2.4, R9.1, R35.1, R_s2.2
/Z_PV: C17.1, C20.1, DZ+.5, DZ-.5, INA3.4, R11.1, R36.1, R_s1.2
GND: 3V6_1.1, 3V6_2.1, BOOT0.3, BOOT1.3, BU1.2, C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.1, C27.1, C28.1, C29.1, C30.1, C31.1, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, C38.2, C39.2, C40.2, C44.2, C45.2, C46.2, C47.2, C48.2, C51.2, C52.2, C53.2, C54.2, C55.2, C60.2, C61.2, C62.2, C63.2, C64.2, C65.2, C_DAC1.2, C_DAC2.2, D4.1, DX+.2, DX-.2, DY+.2, DY-.2, DZ+.2, DZ-.2, Ground_Pins1.1, Ground_Pins1.2, Ground_Pins1.3, Ground_Pins1.4, Ground_Pins1.5, INA1.1, INA1.2, INA2.1, INA2.2, INA3.1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
unnamed: BQ1.1, C56.1, R52.1
unnamed: BQ1.2, C56.2, C57.1, R53.1
unnamed: BQ1.3, R54.1
unnamed: BQ1.4, C58.1
unnamed: BQ1.7, C59.1, R55.2
unnamed: BT1.2, BT2.1, R51.1, R53.2, R54.2
unnamed: C26.2, MAX1.4
unnamed: C27.2, MAX2.4
unnamed: C28.2, MAX3.4
unnamed: C29.2, MAX1.1
unnamed: C30.2, MAX2.1
unnamed: C31.2, MAX3.1
unnamed: C49.1, TPS2.6
unnamed: C49.2, L5.1, TPS2.2
unnamed: C50.1, TPS3.6
unnamed: C50.2, L6.1, TPS3.2
unnamed: D1.2, L2.2, Q1.3
unnamed: D2.2, L3.2, Q2.3
unnamed: D3.2, L4.2, Q3.3
unnamed: D4.2, R65.1
unnamed: MAX1.2, R13.1
unnamed: MAX1.6, Q1.2, R16.1
unnamed: MAX1.8, Q1.1
unnamed: MAX2.2, R14.1
unnamed: MAX2.6, Q2.2, R17.1
unnamed: MAX2.8, Q2.1
unnamed: MAX3.2, R15.1
unnamed: MAX3.6, Q3.2, R18.1
unnamed: MAX3.8, Q3.1
unnamed: FB1.1, POT1.7, R22.2
unnamed: FB2.1, POT2.7, R23.2
unnamed: FB3.1, POT3.7, R24.2
unnamed: G_NMOS1.1, OP1.1, Q4.1, R29.1
unnamed: OP1.3, R27.2, R28.2
unnamed: OP1.4, R29.2, R30.2
unnamed: G_NMOS2.1, OP2.1, Q6.1, R39.1
unnamed: OP2.3, R35.2, R37.2
unnamed: OP2.4, R39.2, R41.2
unnamed: G_NMOS3.1, OP3.1, Q7.1, R40.1
unnamed: OP3.3, R36.2, R38.2
unnamed: OP3.4, R40.2, R42.2
unnamed: Q4.2, R26.2
unnamed: G_PMOS1.1, Q4.3, Q5.1, R25.1
unnamed: Q6.2, R33.2
unnamed: G_PMOS2.1, Q6.3, Q8.1, R31.1
unnamed: Q7.2, R34.2
unnamed: G_PMOS3.1, Q7.3, Q9.1, R32.1
unnamed: Q10.3, Q11.1, R43.1
unnamed: Heater.2, Q12.1
unnamed: Q13.1, Q14.3, Q15.1, R59.1, R60.2
unnamed: Q13.3, Q15.3
unnamed: Q16.3, Q17.2
unnamed: R1.2, STM1.60
unnamed: R2.1, STM1.28
unnamed: R44.2, R45.1, TPS2.4
unnamed: R46.2, R47.1, TPS3.4
unnamed: R65.2, STM1.53
Vcc1: C38.1, D1.1, INA4.4, MAX1.9, MAX1.10, R19.1, R_s6.2, V1_OUT.1
Vcc2: C39.1, C40.1, D2.1, D3.1, INA5.4, INA6.4, MAX2.9, MAX2.10, MAX3.9, MAX3.10, R20.1, R21.1, R_s4.2, R_s5.2, V2_OUT.1, V3_OUT.1

## KiCad design PCB_Design/FULL_PCB/Full_PCB.kicad_pcb

Board: 4 copper layers, 94.0 x 94.0 mm, 165 parts (165 on the bottom side), 92 nets.

Parts:
1k1, 100k1: R; R_0603
5V_1, 5V_2: Jst_Conn; JST_XH_B02B-XH-A_02x2.50mm_Straight
5V_ind1, 5V_ind2: 10u; L_10.4x10.4_H4.8
20m1, 20m2, 20m3, 20m7, 20m8, 20m9, 20m10: R_Shunt; R_0805
BT1, BT2: Battery_Cell; 18650_Holder_FULL
Batt_V_1, Batt_V_2: Jst_Conn; JST_XH_B02B-XH-A_02x2.50mm_Straight
C1, C2, C3, C4, C5, C6: CP; CP_Tantalum_Case-C_EIA-6032-28_Reflow
CAN_BUS1: 5_pin_2.56; Socket_Strip_Straight_1x05_Pitch2.54mm
CBMAX_1, CBMAX_2, CBMAX_3: 68uF; CP_Tantalum_Case-C_EIA-6032-28_Reflow
CBulk1, CBulk2, CBulk3, CBulk4: C; CP_Tantalum_Case-C_EIA-6032-28_Hand
CMAX1, CMAX2, CMAX3: 1uF; C_0805
CMAXREF_1, CMAXREF_2, CMAXREF_3: .22uF; C_0603
CMAX_F_1, CMAX_F_2, CMAX_F_3: 220pF; C_0603
CVCCbuck1, CVCCbuck2: 10u; C_0603
C_Bypass1, C_Bypass2, C_Bypass3, C_Bypass7, C_Bypass8, C_Bypass9, C_Bypass10: .1u; C_0603
C_DAC_Bypass1, C_DAC_Bypass2: C; C_0603
C_INA_BP_1, C_INA_BP_2, C_INA_BP_3: .1u; C_0603
Cboot1, Cboot2: .1uF; C_0805
D1, D2, D3: D_Schottky; D_SMA
DI1, DI2, DI3, DI4, DI5, DI6: MAX40200; SOT-23-5
Ground_Pins1: 2.56_socket_male; Socket_Strip_Straight_1x05_Pitch2.54mm
INA1, INA2, INA3, INA4, INA5, INA6, INA7, INA8, INA9, INA10: INA139; SOT-23-5
L1, L2, L3: L_Small; L_10.4x10.4_H4.8
MAXFB_H_1, MAXFB_H_2, MAXFB_H_3: 100k; R_0603
MAX_FB_L_1, MAX_FB_L_2, MAX_FB_L_3: 22k; R_0603
Nmos_sw1: Logic level Nch mosfet; SOT-23
Q1, Q2, Q3, Q4, Q8, Q9: Q_NMOS_GSD; SOT-23
Q5, Q6, Q7, Q10, Q11, Q12: Q_PMOS_GSD; SOT-23
Q_MAX1, Q_MAX2, Q_MAX3: Q_NMOS_GSD; SOT-23
R1, R2: 10k; R_0603
R1_1, R2_1, R3, R3_1, R4, R5, R9, R10, R11, R12: 100k; R_0603
R1_2, R2_2, R3_2: 200k; R_0603
R6, R13, R14: 220k; R_0603
R7, R8: R; R_0603
RBF_control_pins1: 5_pin_2.56; Socket_Strip_Straight_1x05_Pitch2.54mm
RDivHi1: R; R_0603
RDivLo1: R; R_0603
RMAXSENS_1, RMAXSENS_2, RMAXSENS_3: 0.02; R_0805
R_BDIV_H1: 220k; R_0603
R_BDIV_L1: 100k; R_0603
R_FB1, R_FB2, R_FB3: 100k; R_0603
R_INA_1, R_INA_2, R_INA_3: 100k; R_0603
R_MAX_REF_1, R_MAX_REF_2, R_MAX_REF_3: 100k; R_0603
R_SHUNT_1, R_SHUNT_2, R_SHUNT_3: 20m; R_0805
R_en_div_high1, R_en_div_high2: R; R_0603
R_en_div_low1, R_en_div_low2: R; R_0603
R_enable1, R_enable2: R; R_0603
R_fb_hi1, R_fb_hi2: R; R_0603
R_fb_lo1, R_fb_lo2: R; R_0603
R_pull1: R; R_0603
Solar_X1, Solar_X2: JST_Connector; JST_XH_B02B-XH-A_02x2.50mm_Straight
Solar_Y1, Solar_Y2: JST_Connector; JST_XH_B02B-XH-A_02x2.50mm_Straight
Solar_Z1, Solar_Z2: JST_Connector; JST_XH_B02B-XH-A_02x2.50mm_Straight
Temp_Connector1: JST_conn; JST_XH_B02B-XH-A_02x2.50mm_Straight
U1, U2, U3: MAX668; MSOP-10_3x3mm_Pitch0.5mm
U4: MCP4728; MSOP-10_3x3mm_Pitch0.5mm
U5, U6: TPS54302; SOT-23-6_Handsoldering

Connections:
/3V3: C_Bypass1.1, C_Bypass2.1, C_Bypass3.1, C_Bypass7.1, C_Bypass8.1, C_Bypass9.1, C_Bypass10.1, C_DAC_Bypass1.1, C_DAC_Bypass2.1, C_INA_BP_1.1, C_INA_BP_2.1, C_INA_BP_3.1, INA1.5, INA2.5, INA3.5, INA4.5, INA5.5, INA6.5, INA7.5, INA8.5, INA9.5, INA10.5, R1.2, R2.2, U4.1
/5V_1: 5V_1.2, Q3.2
/5V_2: 5V_2.2, Q4.2
/A_1_I: INA1.1, R_INA_1.1
/A_1_O: INA6.1, R5.1
/A_2_I: INA2.1, R_INA_2.1
/A_3_I: INA3.1, R_INA_3.1
/A_3_O: INA4.1, R3.1
/Batt_V_1: Batt_V_1.2, Q1.2
/Batt_V_2: Batt_V_2.2, Q2.2
/Batt_voltage_divided: R_BDIV_H1.2, R_BDIV_L1.1
/Connectors And Inputs/Ideal_Diodes/X+: DI1.1, DI1.3, Solar_X1.2
/Connectors And Inputs/Ideal_Diodes/X-: DI2.1, DI2.3, Solar_X2.2
/Connectors And Inputs/Ideal_Diodes/Y+: DI3.1, DI3.3, Solar_Y1.2
/Connectors And Inputs/Ideal_Diodes/Y-: DI4.1, DI4.3, Solar_Y2.2
/Connectors And Inputs/Ideal_Diodes/Z+: DI5.1, DI5.3, Solar_Z1.2
/Connectors And Inputs/Ideal_Diodes/Z-: DI6.1, DI6.3, Solar_Z2.2
/Curr_5V_1: INA7.1, R9.1
/Curr_5V_2: INA8.1, R10.1
/Curr_Vbat_1: INA9.1, R11.1
/Curr_Vbat_2: INA10.1, R12.1
/Input/Boost_Converters/I_in_1: CBMAX_1.1, INA1.4, L1.1, R_SHUNT_1.1
/Input/Boost_Converters/I_in_2: CBMAX_2.1, INA2.4, L2.1, R_SHUNT_2.1
/Input/Boost_Converters/I_in_3: CBMAX_3.1, INA3.4, L3.1, R_SHUNT_3.1
/Input/Boost_Converters/MAX668/FB: CMAX_F_1.1, MAXFB_H_1.2, MAX_FB_L_1.1, R_FB1.1, U1.5
/Input/Boost_Converters/MAX668_2/FB: CMAX_F_2.1, MAXFB_H_2.2, MAX_FB_L_2.1, R_FB2.1, U2.5
/Input/Boost_Converters/MAX668_3/FB: CMAX_F_3.1, MAXFB_H_3.2, MAX_FB_L_3.1, R_FB3.1, U3.5
/Input/DAC/Dac_1: R_FB1.2, U4.8
/Input/DAC/Dac_2: R_FB2.2, U4.7
/Input/DAC/Dac_3: R_FB3.2, U4.6
/Input/InaOutput/INA_out/I_out: 20m1.1, INA4.4, Q10.3
/Input/InaOutput/INA_out_2/I_out: 20m2.1, INA5.4, Q11.3
/Input/InaOutput/INA_out_2/Ina_Analog: INA5.1, R4.1
/Input/InaOutput/INA_out_3/I_out: 20m3.1, INA6.4, Q12.3
/Input/InaOutput/I_in_1: 20m1.2, C1.1, C2.1, D1.1, INA4.3, MAXFB_H_1.1, U1.9, U1.10
/Input/InaOutput/I_in_2: 20m2.2, C3.1, C4.1, D2.1, INA5.3, MAXFB_H_2.1, U2.9, U2.10
/Input/InaOutput/I_in_3: 20m3.2, C5.1, C6.1, D3.1, INA6.3, MAXFB_H_3.1, U3.9, U3.10
/Input/InaOutput/PWM_CTRL: Q10.1, Q11.1, Q12.1, R6.2, R13.2, R14.2
/Input/Output_1: Q5.2, Q10.2, Q11.2, Q12.2, R7.1
/MCU_POWER_SW: Nmos_sw1.1, RDivHi1.1, RDivLo1.2
/OUTPUT/5VBuck1/5V_OUT: 5V_ind1.2, 20m7.2, CBulk1.1, CBulk2.1, INA7.3, R_fb_hi1.1
/OUTPUT/5VBuck2/5V_OUT: 5V_ind2.2, 20m8.2, CBulk3.1, CBulk4.1, INA8.3, R_fb_hi2.1
/OUTPUT/INA_BV_2/I_out: 20m10.1, INA10.4, Q2.3
/OUTPUT/Ina_3V6_Out/I_out: 20m8.1, INA8.4, Q4.3
/OUTPUT/Ina_5V_Out/I_out: 20m7.1, INA7.4, Q3.3
/OUTPUT/Ina_BV_1/I_out: 20m9.1, INA9.4, Q1.3
/OUTPUT/POWER_INPUT: 20m9.2, 20m10.2, CVCCbuck1.1, CVCCbuck2.1, INA9.3, INA10.3, Q7.3, R_en_div_high1.1, R_en_div_high2.1, U5.3, U6.3
/SCL: R2.1, U4.2
/SDA: R1.1, U4.3
/V1: R1_1.2, R1_2.1
/V2: R2_1.2, R2_2.1
/V3: R3_1.2, R3_2.1
Battery_+: 100k1.1, BT1.1, Q5.3, Q6.2, RDivHi1.2, R_BDIV_H1.1, R_pull1.2
Battery_-: BT2.2, Q8.3, Q9.3
Battery_middle: BT1.2, BT2.1
GND: 5V_1.1, 5V_2.1, Batt_V_1.1, Batt_V_2.1, C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, CAN_BUS1.1, CBMAX_1.2, CBMAX_2.2, CBMAX_3.2, CBulk1.2, CBulk2.2, CBulk3.2, CBulk4.2, CMAX1.2, CMAX2.2, CMAX3.2, CMAXREF_1.2, CMAXREF_2.2, CMAXREF_3.2, CMAX_F_1.2, CMAX_F_2.2, CMAX_F_3.2, CVCCbuck1.2, CVCCbuck2.2, C_Bypass1.2, C_Bypass2.2, C_Bypass3.2, C_Bypass7.2, C_Bypass8.2, C_Bypass9.2, C_Bypass10.2, C_DAC_Bypass1.2, C_DAC_Bypass2.2, C_INA_BP_1.2, C_INA_BP_2.2, C_INA_BP_3.2, DI1.2, DI2.2, DI3.2, DI4.2, DI5.2, DI6.2, Ground_Pins1.1, Ground_Pins1.2, Ground_Pins1.3, Ground_Pins1.4, Ground_Pins1.5, INA1.2, INA2.2, INA3.2, INA4.2, INA5.2, INA6.2, INA7.2, INA8.2, INA9.2, INA10.2, MAX_FB_L_1.2, MAX_FB_L_2.2, MAX_FB_L_3.2, Q8.2, Q9.2, R1_2.2, R2_2.2, R3.2, R3_2.2, R4.2, R5.2, R6.1, R9.2, R10.2, R11.2, R12.2, R13.1, R14.1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
GND_DSW: 1k1.2, RBF_control_pins1.4
unnamed: 5V_ind1.1, Cboot1.2, U5.2
unnamed: 5V_ind2.1, Cboot2.2, U6.2
unnamed: 1k1.1, 100k1.2, Q8.1, Q9.1
unnamed: CMAX1.1, U1.1
unnamed: CMAX2.1, U2.1
unnamed: CMAX3.1, U3.1
unnamed: CMAXREF_1.1, U1.4
unnamed: CMAXREF_2.1, U2.4
unnamed: CMAXREF_3.1, U3.4
unnamed: Cboot1.1, U5.6
unnamed: Cboot2.1, U6.6
unnamed: D1.2, L1.2, Q_MAX1.3
unnamed: D2.2, L2.2, Q_MAX2.3
unnamed: D3.2, L3.2, Q_MAX3.3
unnamed: Nmos_sw1.2, R8.1
unnamed: Nmos_sw1.3, Q6.1, Q7.1, R_pull1.1
unnamed: Q6.3, Q7.2
unnamed: Q_MAX1.1, U1.8
unnamed: Q_MAX1.2, RMAXSENS_1.1, U1.6
unnamed: Q_MAX2.1, U2.8
unnamed: Q_MAX2.2, RMAXSENS_2.1, U2.6
unnamed: Q_MAX3.1, U3.8
unnamed: Q_MAX3.2, RMAXSENS_3.1, U3.6
unnamed: R_MAX_REF_1.1, U1.2
unnamed: R_MAX_REF_2.1, U2.2
unnamed: R_MAX_REF_3.1, U3.2
unnamed: R_en_div_high1.2, R_en_div_low1.1, R_enable1.1, U5.5
unnamed: R_en_div_high2.2, R_en_div_low2.1, R_enable2.1, U6.5
unnamed: R_fb_hi1.2, R_fb_lo1.1, U5.4
unnamed: R_fb_hi2.2, R_fb_lo2.1, U6.4
RBF1: Q5.1, R7.2, RBF_control_pins1.2, RBF_control_pins1.3, RBF_control_pins1.5
RBF2: R8.2, RBF_control_pins1.1
X+: DI1.5, DI2.5, INA1.3, R1_1.1, R_SHUNT_1.2
Y+: DI3.5, DI4.5, INA2.3, R2_1.1, R_SHUNT_2.2
Z+: DI5.5, DI6.5, INA3.3, R3_1.1, R_SHUNT_3.2

## KiCad design PCB_Design/1 _ fixed with 07mm vias/LM3485/LM3485.kicad_pcb

Board: 2 copper layers, 15 parts (0 on the bottom side), 9 nets.

Parts:
C1, C4: CP; CP_Elec_6.3x5.7
C2, C3: C; C_0805
D1: D_Schottky_Small; D_SMA_Standard
Feedback: 5k; R_0805
GND IN: CONN_01X02; Socket_Strip_Straight_1x02_Pitch2.54mm
J1: CONN_01X01; Socket_Strip_Straight_1x01_Pitch2.54mm
L1: INDUCTOR_SMALL; L_12x12mm_h4.5mm
P2: CONN_01X02; Socket_Strip_Straight_1x02_Pitch2.54mm
Q1: BSS138; SOT-23
RV1, RV2: POT; Potentiometer_Trimmer_Bourns_3266Y
Radj1: 470; R_0805
U1: LM3485; TSSOP-8_3x3mm_Pitch0.65mm

Connections:
GND: C1.2, C4.2, D1.2, Feedback.2, GND IN.1, P2.2, U1.2, U1.6
unnamed: C1.1, C3.1, GND IN.2, Q1.2, RV2.3, U1.8
unnamed: C2.1, C4.1, L1.2, P2.1, RV1.1
unnamed: C2.2, J1.1, RV1.2, U1.4
unnamed: C3.2, RV2.2, Radj1.2, U1.5
unnamed: D1.1, L1.1, Q1.3, U1.1
unnamed: Q1.1, U1.7
unnamed: Feedback.1, RV1.3
unnamed: RV2.1, Radj1.1

## KiCad design PCB_Design/1 _ fixed with 07mm vias/Switches/Switches.kicad_pcb

Board: 2 copper layers, 15 parts (0 on the bottom side), 12 nets.

Parts:
100k: R; R_0603_HandSoldering
D1: D; D_1206
P1: DEP SW; Socket_Strip_Straight_1x02_Pitch2.54mm
P2: BATT- BATT+; Socket_Strip_Straight_1x02_Pitch2.54mm
P3: GND IN; Socket_Strip_Straight_1x02_Pitch2.54mm
P4: MCU GND RBF1 RBF2; Socket_Strip_Straight_1x04_Pitch2.54mm
P5: OUT; Socket_Strip_Straight_1x02_Pitch2.54mm
PMOS1: PCH GDS; SOT-23_Handsoldering
PMOS2, PMOS3: Pch GDS; SOT-23_Handsoldering
R100: R; R_0603_HandSoldering
RDivHi1: R; R_0603_HandSoldering
RDivLo1: R; R_0603_HandSoldering
R_pull1: R; R_0603_HandSoldering
nmos: Logic Nch; SOT-23_Handsoldering

Connections:
BATT+: D1.1, P2.2, PMOS2.2, RDivHi1.2, R_pull1.2
BATT-: P1.2, P2.1
GND: P1.1, P3.1, P4.2, P5.1, RDivLo1.1
LOAD: P5.2, PMOS3.3
MCU_CTRL2: P4.1, RDivHi1.1, RDivLo1.2, nmos.1
unnamed: D1.2, PMOS1.3
unnamed: R100.1, nmos.2
unnamed: PMOS2.1, PMOS3.1, R_pull1.1, nmos.3
unnamed: PMOS2.3, PMOS3.2
RBF_1: 100k.2, P4.4, PMOS1.1
RBF_2: P4.3, R100.2
Vin: 100k.1, P3.2, PMOS1.2

## KiCad design 1 _ fixed with 07mm vias/TPS54302_BUCK/TPS54302.kicad_pcb

Parts:
2PIN2: INPUT; Socket_Strip_Straight_1x02_Pitch2.54mm
CBulk1: C; C_1210
CBulk2: C; CP_Tantalum_Case-D_EIA-7343-31_Hand
CVCCbuck1: 10u; C_1210
Cboot1: .1uF; C_1210
Inductor1: L; L_12x12mm_h4.5mm
J1: CONN_01X03; Socket_Strip_Straight_1x03_Pitch2.54mm
R_fb_hi1: R; R_0603_HandSoldering
R_fb_lo1: R; R_0603_HandSoldering
U1: TPS54302; SOT-23-6_Handsoldering

Connections:
GND: 2PIN2.2, CBulk1.2, CBulk2.2, CVCCbuck1.2, J1.1, R_fb_lo1.2, U1.1 (GND)
unnamed: 2PIN2.1, CBulk1.1, CBulk2.1, Inductor1.2, R_fb_hi1.1
unnamed: CVCCbuck1.1, J1.2, U1.3 (VIN)
unnamed: Cboot1.1, U1.6 (BOOT)
unnamed: Cboot1.2, Inductor1.1, U1.2 (SW)
unnamed: J1.3, U1.5 (EN)
unnamed: R_fb_hi1.2, R_fb_lo1.1, U1.4 (FB)

Notes on the sheet:
Float EN to enable Pull LOW to disable MIGHT BE GOOD TO USE AS OUTPUT CONTROL?

Board: 2 copper layers, 10 parts (0 on the bottom side), 7 nets.

## KiCad design 1 _ fixed with 07mm vias/LTC3115_BuckBoost/LTC3115.kicad_pcb

Parts:
C1: 4.7u; C_0603
Cbst1, Cbst2: .1u; C_0603
CbulkOutTant1: 68u; C_1210
Cbulkout2: 68u; CP_Tantalum_Case-D_EIA-7343-31_Reflow
Cfb1: 33n; C_0603
Cff1: 50pf; C_0603
CinTant1: 68uF; CP_Tantalum_Case-D_EIA-7343-31_Reflow
FB_R1: 50k; R_0603
INPUT1: CONN_01X02; Socket_Strip_Straight_1x02_Pitch2.54mm
Inductor1: 10uH; L_12x12mm_h4.5mm
J1: CONN_01X01; Socket_Strip_Straight_1x01_Pitch2.54mm
Output1: CONN_01X02; Socket_Strip_Straight_1x02_Pitch2.54mm
Q1: Q_PMOS_GDS; SOT-23
RT1: 80.6k; R_0603
Rbot1: 20k; R_0603
Rfb1: 13.7k; R_0603
Rff1: 50k; R_0603
Rtop1: 100k; R_0603
U1: LTC3115; TSSOP-20_4.4x6.5mm_Pitch0.65mm

Connections:
/VIN: CinTant1.1, Q1.3 (S), U1.2 (RUN), U1.13 (Vin), U1.17 (PVin)
GND: C1.2, CbulkOutTant1.1, Cbulkout2.1, CinTant1.2, INPUT1.2, Output1.2, Q1.1 (G), RT1.2, Rbot1.2, U1.1 (PGND), U1.5 (GND), U1.6 (GND), U1.10 (PGND), U1.11 (PGND), U1.20 (PGND)
unnamed: C1.1, U1.12 (Vcc), U1.14 (PVcc), U1.19 (PWM_SYNC)
unnamed: Cbst1.1, Inductor1.1, U1.18 (SW1)
unnamed: Cbst1.2, U1.16 (BST1)
unnamed: Cbst2.1, Inductor1.2, U1.3 (SW2)
unnamed: Cbst2.2, U1.15 (BST2)
unnamed: CbulkOutTant1.2, Cbulkout2.2, Cff1.1, Output1.1, Rtop1.1, U1.4 (PVout)
unnamed: Cfb1.1, FB_R1.2, Rbot1.1, Rff1.2, Rtop1.2, U1.8 (FB)
unnamed: Cfb1.2, Rfb1.1
unnamed: Cff1.2, Rff1.1
unnamed: FB_R1.1, J1.1
unnamed: INPUT1.1, Q1.2 (D)
unnamed: RT1.1, U1.9 (RT)
unnamed: Rfb1.2, U1.7 (VC)

Board: 4 copper layers, 20 parts (0 on the bottom side), 15 nets.
