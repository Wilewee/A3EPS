# Repository Wilewee/A3EPS (continued)

## KiCad design 1 _ fixed with 07mm vias/Max668_BOOST/Max668_2.kicad_pcb

Parts:
C1, C4: 68uF; CP_Tantalum_Case-V_EIA-7343-20_Reflow
C2: 1uF; C_0805
C3: .22uF; C_0805
C5: 68uF; C_1210
C6: 0.1uF; C_0805
C7: 220pF; C_0805
CVCC1: 1uF; C_1206
D1: D_Schottky; D_SMA_Standard
FDS6680: Q_NMOS_GDS; SOT-23_Handsoldering
L1: L_Small; L_12x12mm_h4.5mm
P1, P2: CONN_01X02; Socket_Strip_Straight_1x02_Pitch2.54mm
R2: 218k; R_0805
R3: 25k; R_0805
R4: 100k; R_0805
Rsense1: 0.02; R_2512
U1: MAX668; MSOP-10_3x3mm_Pitch0.5mm
dac1: DAC; Socket_Strip_Straight_1x01

Connections:
/PowerIn: C1.1, CVCC1.2, L1.1, P1.2
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, CVCC1.1, P1.1, P2.2, R3.2, R4.2, Rsense1.2, U1.3 (GND), U1.7 (PGND)
unnamed: C2.1, U1.1 (LDO)
unnamed: C3.1, U1.4 (REF)
unnamed: C4.1, C5.1, C6.1, D1.1 (K), P2.1, R2.1, U1.9 (VCC), U1.10 (SYNC_SHDN)
unnamed: C7.1, R2.2, R3.1, U1.5 (FB), dac1.1
unnamed: D1.2 (A), FDS6680.2 (D), L1.2
unnamed: FDS6680.1 (G), U1.8 (EXT)
unnamed: FDS6680.3 (S), Rsense1.1, U1.6 (CS+)
unnamed: R4.1, U1.2 (FREQ)

Board: 2 copper layers, 19 parts (0 on the bottom side), 10 nets.

## KiCad design 1 _ fixed with 07mm vias/LT3080_and_CAN_transceiver/LT3080_and_CAN_transceiver.kicad_pcb

Parts:
C1: 100n; C_0805_HandSoldering
C2: 10u; C_0805_HandSoldering
C3: 0.1u; C_0805_HandSoldering
P1: CONN_01X03; JST_XH_B03B-XH-A_03x2.50mm_Straight
P2, P3: CONN_01X02; JST_XH_B02B-XH-A_02x2.50mm_Straight
R1: 470; R_0805_HandSoldering
Rterm1: 120; R_0805_HandSoldering
SN1: SN65HVD230; SOIC-8_3.9x4.9mm_Pitch1.27mm
U1: LD1117S33TR; SOT-223-3Lead_TabPin2

Connections:
+3.3V: C2.1, C3.1, P1.3, SN1.3 (Vcc), U1.2 (VO)
+5V: C1.1, P2.1, U1.3 (VI)
CANH: P3.1, Rterm1.1, SN1.7 (CANH)
CANL: P3.2, Rterm1.2, SN1.6 (CANL)
GND: C1.2, C2.2, C3.2, P2.2, R1.1, SN1.2 (GND), U1.1 (GND)
unnamed: R1.2, SN1.8 (Rs)
RXCAN: P1.2, SN1.4 (R)
TXCAN: P1.1, SN1.1 (D)

Notes on the sheet:
LDO regulator. -Used by INAs, DACs, MCU, etc
High-speed mode if <10kOhm
Used for split termination, but can be left floating

Board: 2 copper layers, 45.0 x 24.5 mm, 10 parts (0 on the bottom side), 8 nets.

## Commit log

2017-12-06 Add files via upload
    Project init. This includes many ready subcircuits. Many are missing.
    No PCB layout. Only sch file.
2017-12-06 Small modifications to SCH
2018-01-24 SCH files updated
    schematics for bottom layer parts updated
2018-01-29 Update README.md
    First update
2018-02-01 Cleaned up folder structure and added IO pinout
    IO pinout can be found in documentation
2018-02-02 Update EPS_IO_pins.txt
    Added bus pins
2018-02-04 PCB bottom layer populated
    PCB bottom layer populated, and waiting for top layer to be merged.
2018-02-04 Updated PCB structure tree
    Full_PCB now includes bottom and top layer hierarchical sheets
2018-02-06 Updated
    Full pcb updated
2018-02-08 Update EPS_IO_pins.txt
    Updated IO list.
2018-02-11 Add files via upload
    STM32 done. Other modules are work in progress.
2018-02-16 cleaned up
2018-02-16 Add files via upload
    Schema for full EPS R1 uploaded
2018-02-19 Updated schematics
2018-02-20 Updated Schematics
    Added:
    - digital pot
    - digital loads
    - updated switch sheet to block two ways before battery
2018-02-27 Finalized SCH (beta version) and started pcb
    Capacitor banks might need to be reassigned to other locations.
    No RBF pin on this SCH or PCB.
    Battery gound deployment switch is fully mechanical (no mosfet switch on low side).
    PCB of the prototype started. Main power converters and current measuring devices layed out.
    SCH still requires ESD protection diodes!
2018-02-27 Fixed previous commit
2018-02-27 Fixed gnd at Battery_pack.sch
    No global gnd at BP.sch
2018-02-28 Flow_Diagram
2018-02-28 Flowchart
2018-02-28 Flowchart added
    Flowchart in png and xml
2018-03-06 PCB updated
    Added testpoints and updated PCB
2018-03-07 Updated PCB
    PCB requires mcu to be routed.
    Changed to thermistor connector on pcb
